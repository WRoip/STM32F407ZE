# Keil uVision project STM32F407ZET6.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407ZET6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group DOC
    ../DOC/: readme.txt
  group HARDWARE
    ../HARDWARE/: Wait_Clock.c Led.h Wait_Clock.h Led.c Key.h Key.c Beep.c Beep.h exti_0234.c Pwm1_Led.c
